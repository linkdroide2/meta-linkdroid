DEPENDS_remove_aarch64 = "network-usb-drivers-meta"

#RDEPENDS_${PN}_remove_aarch64 = "enigma2-plugin-drivers-network-usb-rtl8192cu"
#RDEPENDS_${PN}_remove_aarch64 = "enigma2-plugin-drivers-network-usb-rtl8192cu-rev2"

