
RRECOMMENDS_${PN}_append_aarch64 += " \
    enigma2-plugin-extensions-gokodi \
    kodi-aml \
    alsa-utils \
"

