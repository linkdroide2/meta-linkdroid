SUMMARY = "KODI-Addons-meta"
inherit packagegroup

require conf/license/license-gplv2.inc


ALLOW_EMPTY_${PN} = "1"

RDEPENDS_${PN} = " \
     \
    "

