SRC_URI_append_aarch64 = " file://0001-add-HBGIC-for-wetek.patch"

